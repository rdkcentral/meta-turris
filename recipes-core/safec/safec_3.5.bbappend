SRC_URI_remove = "file://0001-memrchr-Use-_ISOC11_SOURCE-only-with-glibc.patch"

CPPFLAGS_remove = "-D_GNU_SOURCE"
