RDEPENDS_${PN}_class-target_remove_dunfell = " cpp cpp-symlinks"
