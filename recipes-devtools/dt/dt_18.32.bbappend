FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append = "file://dt-turris.patch \
		"
