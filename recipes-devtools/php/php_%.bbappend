EXTRA_OECONF_append = " --enable-cgi "

CFLAGS_append = " -DHAVE_LIBDL "
LDFLAGS_append = " -ldl "
