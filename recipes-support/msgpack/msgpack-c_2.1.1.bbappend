FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " file://copying-non-trivial-object-error.patch"
