DEPENDS += "gtest"
