FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://replace-strncpy-by-memcpy.patch"
