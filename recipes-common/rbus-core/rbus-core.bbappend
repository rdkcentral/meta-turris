DEPENDS_dunfell += "msgpack-c glibc rtmessage"

LDFLAGS_append = " -lrtMessage"
