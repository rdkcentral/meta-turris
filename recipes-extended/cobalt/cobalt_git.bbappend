DEPENDS = "userland"
DEPENDS_dunfell = "bison-native"

inherit pythonnative
