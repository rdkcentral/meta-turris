require ccsp_common_turris.inc

LDFLAGS_append_dunfell = " -lpthread"
