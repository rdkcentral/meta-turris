SRC_URI_remove = "${RDKB_CCSP_CPC_ROOT_GIT}/Xconf/generic;protocol=${RDK_GIT_PROTOCOL};branch=${CCSP_GIT_BRANCH};name=CcspXconf"
SRC_URI += "${CMF_GIT_ROOT}/rdkb/components/opensource/ccsp/Xconf;protocol=${CMF_GIT_PROTOCOL};branch=${CMF_GIT_BRANCH};name=CcspXconf"
