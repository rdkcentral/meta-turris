CFLAGS_append = " -DWIFI_HAL_VERSION_3 "
CFLAGS_append = " -DWIFI_HAL_VERSION_3_PHASE2 "
