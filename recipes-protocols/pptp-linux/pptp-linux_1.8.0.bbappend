FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://pptp-linux-turris.patch"


