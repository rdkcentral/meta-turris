FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
OPENSYNC_VENDOR_URI += "file://turris-bci-target.patch;patchdir=${WORKDIR}/git/vendor/turris"
