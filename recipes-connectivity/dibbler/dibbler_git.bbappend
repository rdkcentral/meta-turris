CLIENT_NOTIFY_BSD = "git"
