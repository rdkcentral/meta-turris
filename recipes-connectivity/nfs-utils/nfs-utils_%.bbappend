DEPENDS_append = " libevent"

CFLAGS_append = " \
    -I${STAGING_INCDIR}/libevent \
"
